# Keil uVision project QF-TEST-CMOS7670_WithFIFO.uvprojx, settings and files
target ESSN_WCR_A (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: QF-TEST-CMOS7670_WithFIFO +hex
  AfterMake: D:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin  -o program.bin  ./../OBJ/QF-TEST-CMOS7670_WithFIFO.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,KEIL,ESSN_WCR_A
  c include: ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\USER\INC;..\..\drivers;..\..\USER\jpeg;..\..\USER\INC;..\..\RTT
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../../USER/SRC/: stm32f10x_it.c main.c Nvic_Exit.c USART.c I2C.c sys.c fifo.c comfunc.c alloter.c hardware_layer.c uart_fifo.c bitmap.c protcl_7e.c task_handle.c
    ../../USER/: usart1_trainsmit.c
  group STM32_LIB
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_exti.c stm32f10x_tim.c stm32f10x_dma.c stm32f10x_crc.c stm32f10x_flash.c stm32f10x_spi.c stm32f10x_pwr.c stm32f10x_iwdg.c
  group MDK_STARTUP
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../USER/SRC/: system_stm32f10x.c
  group driver
    ../../drivers/: uart.c
  group camera
    ../../USER/SRC/camera/: camera.c camera_dev.c gc0308.c OV7670.c
  group RTT
    ../../RTT/: SEGGER_RTT.c SEGGER_RTT_printf.c
target ESSN_WCR_B (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: QF-TEST-CMOS7670_WithFIFO +hex
  AfterMake: C:\Keil_v5\ARM\ARMCC\bin\fromelf.exe --bin  -o program.bin  ./../OBJ/QF-TEST-CMOS7670_WithFIFO.axf
  AfterMake: python  ..\..\..\..\..\tools\autopackage\autoPackage.py ESSN-WCR-B
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,KEIL,ESSN_WCR_B
  c include: ..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\USER\INC;..\..\drivers;..\..\USER\jpeg;..\..\USER\INC
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target ESSN_WCR_P (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: QF-TEST-CMOS7670_WithFIFO +hex
  AfterMake: as above
  AfterMake: python  ..\..\..\..\..\tools\autopackage\autoPackage.py ESSN-WCR-P
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,KEIL,ESSN_WCR_P
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8002000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
target ESSN_WCR_P_Debug (5060300::V5.06 update 3 (build 300)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.0
  cpu: as above
  output: QF-TEST-CMOS7670_WithFIFO +hex
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER,KEIL,KEIL_DEBUG,ESSN_WCR_P
  c include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
software components: CMSIS:CORE 5.5.0
